# Keil uVision project Blinky.uvprojx, settings and files
target LPC4357 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(204000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: iap_interface.c eeprom_interface.c crc32.c boot_interface.c nxp_iap.c
  group Documentation
    ./: Abstract.txt
target LPC4357 RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: as above
  output: Blinky +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20001000 size 0x8000
target LPC4357 Ext. Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 wLevel=2
  asm define: NO_CRP
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0

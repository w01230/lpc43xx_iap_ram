# Keil uVision project nxp_lpc43xx.uvprojx, settings and files
target lpc4357_ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nxp_lpc43xx +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20001000 size 0x8000
  group source
    ./Source/: eeprom.c flash.c crc32.c boot_op.c main.c otp.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
